
EXTRA_OECONF_append += "LDFLAGS='${LDFLAGS} -Wl,-rpath-link=${STAGING_DIR_HOST}/lib64 -Wl,-rpath-link=${STAGING_DIR_HOST}/usr/lib64'"
