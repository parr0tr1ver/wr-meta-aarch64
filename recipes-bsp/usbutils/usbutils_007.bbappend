
EXTRA_OEMAKE_append += "LDFLAGS+='-lpthread'"
