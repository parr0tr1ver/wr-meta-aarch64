
EXTRA_OEMAKE_append += "OPT='-Wl,-rpath-link=${STAGING_DIR_HOST}/lib64'"
