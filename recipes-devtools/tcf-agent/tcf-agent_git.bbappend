
EXTRA_OEMAKE_append += "CFLAGS='${CFLAGS} -Wl,-rpath-link=${STAGING_DIR_HOST}/lib64'"
