FILESEXTRAPATHS_prepend := "${THISDIR}/libcap:"

SRC_URI += "file://fix-lack-libattr.patch"
